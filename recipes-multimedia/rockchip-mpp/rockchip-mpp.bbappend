SRCREV = "eff1e2ede31817c7d6fbe9c62421ab4955f962b7"
SRC_URI = "git://github.com/JeffyCN/mirrors.git;protocol=https;nobranch=1;branch=mpp-dev;"
