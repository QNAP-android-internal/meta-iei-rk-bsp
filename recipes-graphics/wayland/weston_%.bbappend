SRC_URI:remove = "git://github.com/JeffyCN/weston;protocol=https;nobranch=1;branch=${PV}_2024_04_03;"
SRC_URI:append = " git://github.com/JeffyCN/weston;protocol=https;nobranch=1;branch=${PV}_2024_06_19;"
