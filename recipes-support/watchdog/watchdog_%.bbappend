# Ensure watchdog service starts on boot
SYSTEMD_AUTO_ENABLE = "enable"
